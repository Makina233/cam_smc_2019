# IAR project cam_smc_2019.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60DZ10
  ICCARM.CCIncludePath2: ..\..\core_src\bsp\k60_driver\CORE; ..\..\core_src\bsp\k60_driver\CORE\CMSIS\Inc; ..\..\core_src\bsp\k60_driver\CORE\kinetis; ..\..\core_src\bsp\k60_driver\VCAN_K60\inc; ..\..\core_src\bsp\board_driver; ..\..\core_src\api; ..\..\core_src\app
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cam_smc_2019.hex
  ILINK.IlinkOutputFile: cam_smc_2019.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N512.icf
  ILINK.IlinkAdditionalLibs: ..\..\core_src\bsp\k60_driver\CORE\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group api
    ../../core_src/api/: mecanum_wheel.c mecanum_wheel.h pid.c pid.h
  group app
    ../../core_src/app/: main.c timer_interrupt.c timer_interrupt.h
  group bsp/bsp_board_driver
    ../../core_src/bsp/board_driver/: key.c key.h lcd_sgp18t.c lcd_sgp18t.h mt9v034.c mt9v034.h oled.c oled.h pwm.c pwm.h
  group bsp/bsp_k60_driver/core
    ../../core_src/bsp/k60_driver/CORE/: startup_MK60DZ10.s system_MK60DZ10.c system_MK60DZ10.h
  group bsp/bsp_k60_driver/vcan_k60
    ../../core_src/bsp/k60_driver/VCAN_K60/inc/: common.h misc.h MK60_adc.h MK60_conf.h MK60_dma.h MK60_DWT.h MK60_flash.h MK60_FTM.h MK60_gpio.h MK60_gpio_cfg.h MK60_i2c.h MK60_lptmr.h MK60_mcg.h MK60_pit.h MK60_port.h MK60_spi.h MK60_SysTick.h MK60_uart.h MK60_wdog.h PORT_cfg.h vectors.h
    ../../core_src/bsp/k60_driver/VCAN_K60/src/: misc.c MK60_adc.c MK60_conf.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_pit.c MK60_port.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_wdog.c vectors.c
