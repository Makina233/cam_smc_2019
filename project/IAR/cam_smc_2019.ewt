<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>api</name>
    <file>
      <name>$PROJ_DIR$\..\..\core_src\api\mecanum_wheel.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\core_src\api\mecanum_wheel.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\core_src\api\pid.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\core_src\api\pid.h</name>
    </file>
  </group>
  <group>
    <name>app</name>
    <file>
      <name>$PROJ_DIR$\..\..\core_src\app\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\core_src\app\timer_interrupt.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\core_src\app\timer_interrupt.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\core_src\app\user_interface.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\core_src\app\user_interface.h</name>
    </file>
  </group>
  <group>
    <name>bsp</name>
    <group>
      <name>bsp_board_driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\key.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\lcd_sgp18t.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\lcd_sgp18t.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\mt9v034.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\mt9v034.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\oled.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\oled.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\pwm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\core_src\bsp\board_driver\pwm.h</name>
      </file>
    </group>
    <group>
      <name>bsp_k60_driver</name>
      <group>
        <name>core</name>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\CORE\startup_MK60DZ10.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\CORE\system_MK60DZ10.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\CORE\system_MK60DZ10.h</name>
        </file>
      </group>
      <group>
        <name>vcan_k60</name>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\common.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\misc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\misc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_adc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_conf.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_conf.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_dma.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_dma.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_DWT.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_DWT.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_flash.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_ftm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_FTM.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_gpio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_gpio_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_i2c.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_lptmr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_lptmr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_mcg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_mcg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_pit.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_pit.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_port.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_port.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_spi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_spi.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_SysTick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_SysTick.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_uart.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\MK60_wdog.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\MK60_wdog.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\PORT_cfg.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\src\vectors.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\core_src\bsp\k60_driver\VCAN_K60\inc\vectors.h</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>README</name>
    <file>
      <name>$PROJ_DIR$\..\..\README.md</name>
    </file>
  </group>
</project>


